<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>variable_chooser_1</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>(0,0,0,1)</value></param>
<param><key>choices</key><value>[(1,0,0,0),(0,1,0,0),(0,0,1,0),(0,0,0,1)]</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>type</key><value>radio_buttons</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
</block>
<block>
<key>random_source_x</key>
<param><key>id</key><value>random_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>num_samps</key><value>1000</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>gr_chunks_to_symbols_xx</key>
<param><key>id</key><value>gr_chunks_to_symbols_xx_0</value></param>
<param><key>in_type</key><value>short</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>complex(1,0),complex(0,1),complex(-1,0),complex(0,-1)</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>num_ports</key><value>1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>delay</value></param>
<param><key>label</key><value>delay</value></param>
<param><key>value</key><value>3</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>50</value></param>
<param><key>num_steps</key><value>50</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>trellis_viterbi_x</key>
<param><key>id</key><value>trellis_viterbi_x_0</value></param>
<param><key>type</key><value>s</value></param>
<param><key>fsm_args</key><value>1,2,(5,7)</value></param>
<param><key>block_size</key><value>1024*16</value></param>
<param><key>init_state</key><value>0</value></param>
<param><key>final_state</key><value>-1</value></param>
</block>
<block>
<key>gr_short_to_float</key>
<param><key>id</key><value>gr_short_to_float_0_0</value></param>
</block>
<block>
<key>gr_noise_source_x</key>
<param><key>id</key><value>gr_noise_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>noise_type</key><value>gr.GR_GAUSSIAN</value></param>
<param><key>amp</key><value>0.01</value></param>
<param><key>seed</key><value>42</value></param>
</block>
<block>
<key>trellis_encoder_xx</key>
<param><key>id</key><value>trellis_encoder_xx_0</value></param>
<param><key>type</key><value>bs</value></param>
<param><key>fsm_args</key><value>1,2,(5,7)</value></param>
<param><key>init_state</key><value>0</value></param>
</block>
<block>
<key>gr_interp_fir_filter_xxx</key>
<param><key>id</key><value>gr_interp_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>5</value></param>
<param><key>taps</key><value>firdes.root_raised_cosine(1,samp_rate, samp_rate, 0.5, 5)</value></param>
</block>
<block>
<key>gr_add_xx</key>
<param><key>id</key><value>gr_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>howto_demod_filterbank_ccvc</key>
<param><key>id</key><value>howto_demod_filterbank_ccvc_1</value></param>
<param><key>numvec</key><value>1</value></param>
<param><key>filterbank_args</key><value>1,5,firdes.root_raised_cosine(1,samp_rate,samp_rate, 0.5, 5)</value></param>
</block>
<block>
<key>gr_fir_filter_xxx</key>
<param><key>id</key><value>gr_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>taps</key><value>(delay-1)*[0,]+[1,]+(51-delay)*[0,]</value></param>
</block>
<block>
<key>trellis_metrics_x</key>
<param><key>id</key><value>trellis_metrics_x_0</value></param>
<param><key>type</key><value>c</value></param>
<param><key>card</key><value>4</value></param>
<param><key>dim</key><value>1</value></param>
<param><key>table</key><value>(complex(1,0),complex(0,1),complex(-1,0),complex(0,-1))</value></param>
<param><key>metric_type</key><value>digital.TRELLIS_EUCLIDEAN</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>1</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0.001</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>win_size</key><value>60,60</value></param>
<param><key>trig_mode</key><value>gr.gr_TRIG_MODE_NORM</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>gr_throttle</key>
<param><key>id</key><value>gr_throttle_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<connection><source_block_id>gr_throttle_0_0</source_block_id><sink_block_id>trellis_encoder_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>trellis_metrics_x_0</source_block_id><sink_block_id>trellis_viterbi_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>trellis_viterbi_x_0</source_block_id><sink_block_id>gr_short_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>trellis_encoder_xx_0</source_block_id><sink_block_id>gr_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_chunks_to_symbols_xx_0</source_block_id><sink_block_id>gr_interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_fir_filter_xxx_0</source_block_id><sink_block_id>trellis_metrics_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>random_source_x_0</source_block_id><sink_block_id>gr_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_fir_filter_xxx_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_short_to_float_0_0</source_block_id><sink_block_id>gr_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_noise_source_x_0</source_block_id><sink_block_id>gr_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_interp_fir_filter_xxx_0</source_block_id><sink_block_id>gr_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_add_xx_0</source_block_id><sink_block_id>howto_demod_filterbank_ccvc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>howto_demod_filterbank_ccvc_1</source_block_id><sink_block_id>gr_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
